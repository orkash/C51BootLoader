# Keil uVision project C51BootLoad.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: C51BootLoad +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\soure
  group Source Group 1
    ./soure/: Flash.c main.c Uart.c Delay.c
